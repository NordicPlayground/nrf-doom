# Keil uVision project fatfs_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: config;..\..\SDK\components;..\..\SDK\components\boards;..\..\SDK\components\drivers_nrf\nrf_soc_nosd;..\..\SDK\components\libraries\atomic;..\..\SDK\components\libraries\balloc;..\..\SDK\components\libraries\block_dev;..\..\SDK\components\libraries\block_dev\sdc;..\..\SDK\components\libraries\bsp;..\..\SDK\components\libraries\delay;..\..\SDK\components\libraries\experimental_section_vars;..\..\SDK\components\libraries\fifo;..\..\SDK\components\libraries\log;..\..\SDK\components\libraries\log\src;..\..\SDK\components\libraries\memobj;..\..\SDK\components\libraries\ringbuf;..\..\SDK\components\libraries\sdcard;..\..\SDK\components\libraries\strerror;..\..\SDK\components\libraries\uart;..\..\SDK\components\libraries\util;..;..\..\SDK\external\fatfs\port;..\..\SDK\external\fatfs\src;..\..\SDK\external\fprintf;..\..\SDK\external\protothreads;..\..\SDK\external\protothreads\pt-1.4;..\..\SDK\external\segger_rtt;..\..\SDK\integration\nrfx;..\..\SDK\integration\nrfx\legacy;..\..\SDK\modules\nrfx;..\..\SDK\modules\nrfx\drivers\include;..\..\SDK\modules\nrfx\hal;..\..\SDK\modules\nrfx\mdk;..\doom;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: config;..\..\SDK\components;..\..\SDK\components\boards;..\..\SDK\components\drivers_nrf\nrf_soc_nosd;..\..\SDK\components\libraries\atomic;..\..\SDK\components\libraries\balloc;..\..\SDK\components\libraries\block_dev;..\..\SDK\components\libraries\block_dev\sdc;..\..\SDK\components\libraries\bsp;..\..\SDK\components\libraries\delay;..\..\SDK\components\libraries\experimental_section_vars;..\..\SDK\components\libraries\fifo;..\..\SDK\components\libraries\log;..\..\SDK\components\libraries\log\src;..\..\SDK\components\libraries\memobj;..\..\SDK\components\libraries\ringbuf;..\..\SDK\components\libraries\sdcard;..\..\SDK\components\libraries\strerror;..\..\SDK\components\libraries\uart;..\..\SDK\components\libraries\util;..;..\..\SDK\external\fatfs\port;..\..\SDK\external\fatfs\src;..\..\SDK\external\fprintf;..\..\SDK\external\protothreads;..\..\SDK\external\protothreads\pt-1.4;..\..\SDK\external\segger_rtt;..\..\SDK\integration\nrfx;..\..\SDK\integration\nrfx\legacy;..\..\SDK\modules\nrfx;..\..\SDK\modules\nrfx\drivers\include;..\..\SDK\modules\nrfx\hal;..\..\SDK\modules\nrfx\mdk;config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../: main.c retarget.c
    config/: sdk_config.h
  group Board Definition
    ../../SDK/components/boards/: boards.c
  group FATFS
    ../../SDK/external/fatfs/port/: diskio_blkdev.c
    ../../SDK/external/fatfs/src/: ff.c
  group nRF_Drivers
    ../../SDK/integration/nrfx/legacy/: nrf_drv_spi.c nrf_drv_uart.c
    ../../SDK/modules/nrfx/soc/: nrfx_atomic.c
    ../../SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../SDK/modules/nrfx/drivers/src/: nrfx_spi.c nrfx_spim.c nrfx_uart.c nrfx_uarte.c
  group nRF_Libraries
    ../../SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../SDK/components/libraries/fifo/: app_fifo.c
    ../../SDK/components/libraries/sdcard/: app_sdcard.c
    ../../SDK/components/libraries/uart/: app_uart_fifo.c
    ../../SDK/components/libraries/atomic/: nrf_atomic.c
    ../../SDK/components/libraries/balloc/: nrf_balloc.c
    ../../SDK/components/libraries/block_dev/sdc/: nrf_block_dev_sdc.c
    ../../SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../SDK/components/libraries/memobj/: nrf_memobj.c
    ../../SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group Common_i
    ../: i_timer.c i_system.c i_input.c i_video.c i_joystick.c i_sound.c
  group Common_m
    ../: m_argv.c m_config.c m_misc.c m_controls.c
  group Doom
    ../doom/: d_main.c doomstat.c
  group Common
    ../: z_native.c
  group Common_d
    ../: d_iwad.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
